# Repository hotkeysoft/wizardElectronicGame-kicad

File README.md:

# Wizard Electronic Game
Rev A October 2019

### Handheld Electronic Game
- ATmega328P microcontroller running at 12MHz
- 10 push buttons with red LEDs
- 4 buttons for game mode
- Buzzer
- Tag-Connect for programming
- Runs on 3 AAA batteries

The microcontroller runs a [TMS1000-series emulator](https://github.com/hotkeysoft/emulators) I made.

Two ROMs are loaded on the emulator: **Merlin (TMS1100)** and **Master Merlin (TMS1400)** (by *Parker Brothers*).

By default the game boots in Merlin mode. To play Master Merlin, press any of the four mode buttons while turning on the console.

Images
============
|Front                                                 | Back                                              |
|------------------------------------------------------|---------------------------------------------------|
|||

### Schematics (pdf)
- [Complete schematics](./img/schema.pdf)

### PCB Images (svg)
- [Top](./img/pcb-front.svg)
- [Bottom](./img/pcb-back.svg)

## KiCad design WizardGame.kicad_pcb

Parts:
C1, C2: 18pF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C3, C4, C5, C6: 100nF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1: AVR-ISP-6; Tag-Connect_TC2030-IDC-NL_2x03_P1.27mm_Vertical
J2: BATTERY; PinHeader_1x02_P2.54mm_Vertical
LS1: SPEAKER; PinHeader_1x02_P2.54mm_Vertical
MH1, MH2, MH3, MH4: CASE; MountingHole_2.7mm_Pad
R1: 10K; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R2: 330K; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R3: 100K; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
RN1, RN2, RN3: 1K; R_Array_Convex_4x1206
SW1: 0; SW_PUSH-12mm_LED
SW2: 1; SW_PUSH-12mm_LED
SW3: 2; SW_PUSH-12mm_LED
SW4: 3; SW_PUSH-12mm_LED
SW5: 4; SW_PUSH-12mm_LED
SW6: 5; SW_PUSH-12mm_LED
SW7: 6; SW_PUSH-12mm_LED
SW8: 7; SW_PUSH-12mm_LED
SW9: 8; SW_PUSH-12mm_LED
SW10: 9; SW_PUSH-12mm_LED
SW11: 10; SW_PUSH-12mm_LED
SW12: NEW GAME; SW_PUSH_6mm
SW13: SAME GAME; SW_PUSH_6mm
SW14: HIT ME; SW_PUSH_6mm
SW15: COMP TURN; SW_PUSH_6mm
SW16: POWER; SW_CuK_OS102011MA1QN1_SPDT_Angled
U1: ATmega328P-AU; TQFP-32_7x7mm_P0.8mm
Y1: 12MHz; Crystal_HC49-4H_Vertical

Connections:
+BATT: J2.2, SW16.2 (B)
/ADC7: R2.1, R3.2, U1.22
/AREF: C4.1, U1.20
/BUZZER: LS1.2, U1.28
/K1: SW1.2, SW5.2, SW9.2, U1.30
/K2: SW2.2, SW6.2, SW10.2, SW15.2 (B), U1.31
/K4: SW4.2, SW8.2, SW13.2 (B), SW14.2 (B), U1.32
/K8: SW3.2, SW7.2, SW11.2, SW12.2 (B), U1.1
/LED0: RN1.1 (R1.1), SW1.4 (A)
/LED1: RN1.2 (R2.1), SW2.4 (A)
/LED2: RN1.3 (R3.1), SW3.4 (A)
/LED3: RN1.4 (R4.1), SW4.4 (A)
/LED4: RN2.1 (R1.1), SW5.4 (A)
/LED5: RN2.2 (R2.1), SW6.4 (A)
/LED6: RN2.3 (R3.1), SW7.4 (A)
/LED7: RN2.4 (R4.1), SW8.4 (A)
/LED8: RN3.1 (R1.1), SW9.4 (A)
/LED9: RN3.2 (R2.1), SW10.4 (A)
/LED10: RN3.3 (R3.1), SW11.4 (A)
/O0: SW1.1, SW2.1, SW3.1, SW4.1, U1.2
/O1: SW5.1, SW6.1, SW7.1, SW8.1, U1.9
/O2: SW9.1, SW10.1, SW11.1, SW13.1 (A), U1.10
/O3: SW12.1 (A), SW14.1 (A), SW15.1 (A), U1.11
/R0: RN1.8 (R1.2), U1.12
/R1: RN1.7 (R2.2), U1.13
/R2: RN1.6 (R3.2), U1.14
/R6: RN2.6 (R3.2), U1.23
/R7: RN2.5 (R4.2), U1.24
/R8: RN3.8 (R1.2), U1.25
/R9: RN3.7 (R2.2), U1.26
/R10: RN3.6 (R3.2), U1.27
/XTAL1: C1.2, U1.7, Y1.1
/XTAL2: C2.2, U1.8, Y1.2
GND: C1.1, C2.1, C3.1, C4.2, C5.1, C6.1, J1.6 (GND), J2.1, LS1.1, MH1.1, MH2.1, MH3.1, MH4.1, R3.1, SW1.3 (K), SW2.3 (K), SW3.3 (K), SW4.3 (K), SW5.3 (K), SW6.3 (K), SW7.3 (K), SW8.3 (K), SW9.3 (K), SW10.3 (K), SW11.3 (K), U1.3, U1.5, U1.21
MISO: J1.1 (MISO), RN2.8 (R1.2), U1.16
MOSI: J1.4 (MOSI), RN1.5 (R4.2), U1.15
SCK: J1.3 (SCK), RN2.7 (R2.2), U1.17
VCC: C3.2, C5.2, C6.2, J1.2 (VCC), R1.2, R2.2, SW16.3 (C), U1.4, U1.6, U1.18
~RESET: J1.5 (~RST), R1.1, U1.29

Board: 2 copper layers, 60.0 x 125.0 mm, 37 parts (2 on the bottom side), 39 nets.

## Commit log

2019-10-13 Merlin + Simon Games
2019-10-14 Routing
2019-10-22 Updated silkscreen, added plots
2019-10-22 Added fab
2019-10-23 Removed battery holes
2019-10-24 Added renders
2019-11-01 Added source code
2019-11-04 Added dimensions. Changed resistor value for LEDs. Fixed mode switch code
2020-07-28 Renamed, cleanup
2020-07-28 Create LICENSE
2020-07-28 Added submodule, updated paths
2020-07-28 rename
